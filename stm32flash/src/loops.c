#include <stdint.h>
#include "task.h"
#define WIDTH 12
uint16_t testarr[1536];
uint16_t alpha_F[] = {

    0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0x0000, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 
    0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff, 0xffff 

};
uint32_t index =0;
int count =0;

void bmp_size_up(void* args){
    int scalar =4;
    int n = 96;

    uint8_t offset = scalar*WIDTH;
    
    int row_offset = WIDTH*scalar*scalar;
    int temp = 0;
    while(1){
        temp=0;
        count=0;
        index =0;

        for(int i = 0; i < n; ++i){
            for(int j = 0; j < scalar; ++j){
                for(int k = 0; k < scalar; ++k){
                    if(index >= 1540){
                        __asm__ volatile("BKPT");


                    }
                    index = ((i%WIDTH)*scalar)+(j*offset)+temp+k;
                    testarr[index] = alpha_F[i];
                }
            }
            if((i+1)%WIDTH==0){
                count++;
                temp += row_offset;
            }
        }
    }
}
